options:
  parameters:
    author: trave
    generate_options: qt_gui
    id: OOKDemod
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: baudrate
  id: variable
  parameters:
    value: '.4'
  states: {}
- name: cutoff
  id: variable
  parameters:
    value: '.05'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 30e3
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: 2*baudrate
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: byte
    waveform: analog.GR_SQR_WAVE
  states: {state: disabled}
- name: analog_simple_squelch_cc_0
  id: analog_simple_squelch_cc
  parameters:
    alpha: '.001'
    threshold: '-30'
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {state: disabled}
- name: blocks_complex_to_mag_1
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: C:\Users\trave\Desktop\GitHub\GNC-Team\testing\hackrf\output.txt
    type: byte
  states: {}
- name: blocks_float_to_char_0
  id: blocks_float_to_char
  parameters:
    scale: '1'
  states: {}
- name: blocks_keep_one_in_n_0
  id: blocks_keep_one_in_n
  parameters:
    n: int(samp_rate/baudrate)
    type: float
  states: {}
- name: blocks_pack_k_bits_bb_0
  id: blocks_pack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_sample_and_hold_xx_0
  id: blocks_sample_and_hold_xx
  parameters:
    type: float
  states: {state: disabled}
- name: blocks_threshold_ff_0
  id: blocks_threshold_ff
  parameters:
    high: cutoff
    init: '0'
    low: cutoff
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    bb_gain0: '20'
    freq0: 433.333e6
    gain0: '10'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    name: '"magnitude"'
    size: '10'
    srate: samp_rate
    type: float
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    name: '"square wave"'
    size: '1024'
    srate: samp_rate
    type: float
  states: {state: disabled}
- name: qtgui_time_sink_x_0_1_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    grid: 'True'
    marker1: '0'
    name: '"1 in N"'
    size: '100'
    srate: baudrate
    type: float
  states: {state: disabled}
- name: qtgui_time_sink_x_0_1_0_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    name: '"threshold"'
    size: '1024'
    srate: samp_rate
    type: float
  states: {state: disabled}

connections:
- [analog_sig_source_x_0, '0', blocks_char_to_float_0, '0']
- [analog_sig_source_x_0, '0', blocks_sample_and_hold_xx_0, '1']
- [analog_simple_squelch_cc_0, '0', blocks_complex_to_mag_1, '0']
- [blocks_char_to_float_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_complex_to_mag_1, '0', blocks_sample_and_hold_xx_0, '0']
- [blocks_complex_to_mag_1, '0', blocks_threshold_ff_0, '0']
- [blocks_complex_to_mag_1, '0', qtgui_time_sink_x_0, '0']
- [blocks_float_to_char_0, '0', blocks_pack_k_bits_bb_0, '0']
- [blocks_keep_one_in_n_0, '0', blocks_float_to_char_0, '0']
- [blocks_keep_one_in_n_0, '0', qtgui_time_sink_x_0_1_0, '0']
- [blocks_pack_k_bits_bb_0, '0', blocks_file_sink_0, '0']
- [blocks_sample_and_hold_xx_0, '0', blocks_threshold_ff_0, '0']
- [blocks_threshold_ff_0, '0', blocks_keep_one_in_n_0, '0']
- [blocks_threshold_ff_0, '0', qtgui_time_sink_x_0_1_0_0, '0']
- [osmosdr_source_0, '0', analog_simple_squelch_cc_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.4.0
