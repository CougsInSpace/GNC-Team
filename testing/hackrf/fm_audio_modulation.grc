options:
  parameters:
    generate_options: qt_gui
    id: send
    output_language: python
    title: Frequency
  states: {}

blocks:
- name: freq
  id: variable_qtgui_range
  parameters:
    outputmsgname: value
    showports: 'False'
    start: 87.7e6
    step: 200e3
    stop: 107.7e6
    value: station
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '480000'
  states: {}
- name: station
  id: variable
  parameters:
    value: 87.7e6
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '30'
    quad_rate: samp_rate
  states: {}
- name: analog_wfm_tx_0
  id: analog_wfm_tx
  parameters:
    audio_rate: int(samp_rate/10)
    fh: '-1.0'
    max_dev: 75e3
    quad_rate: samp_rate
    tau: '25e-6'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '16000'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: C:\Users\trave\Desktop\GitHub\GNC-Team\testing\hackrf\fm_output.txt
    type: complex
  states: {state: disabled}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: C:\Users\trave\Desktop\GitHub\GNC-Team\testing\hackrf\go cougs.wav
    repeat: 'True'
  states: {}
- name: osmosdr_sink_0
  id: osmosdr_sink
  parameters:
    bb_gain0: '20'
    freq0: freq
    gain0: '10'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: none
    type: fc32
  states: {state: disabled}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: '90'
    type: ccc
  states: {state: disabled}
- name: rational_resampler_xxx_1
  id: rational_resampler_xxx
  parameters:
    decim: '30'
    interp: '1'
    type: ccc
  states: {state: disabled}

connections:
- [analog_wfm_rcv_0, '0', audio_sink_0, '0']
- [analog_wfm_tx_0, '0', analog_wfm_rcv_0, '0']
- [analog_wfm_tx_0, '0', rational_resampler_xxx_0, '0']
- [analog_wfm_tx_0, '0', rational_resampler_xxx_1, '0']
- [blocks_throttle_0, '0', analog_wfm_tx_0, '0']
- [blocks_wavfile_source_0, '0', blocks_throttle_0, '0']
- [rational_resampler_xxx_0, '0', osmosdr_sink_0, '0']
- [rational_resampler_xxx_1, '0', blocks_file_sink_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.4.0
